# Keil uVision project FATFS.uvprojx, settings and files
target FATFS (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: FATFS +hex
  c flags: Optim=1
  c define: STM32F40 STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\SRAM;..\HARDWARE\SDIO;..\MALLOC;..\USMART;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\FATFS\exfuns;..\FATFS\src;..\FWLIB\inc;..\HARDWARE\DMA;..\SYSTEM\USART;..\FATFS\src;..\HARDWARE\STMFLASH;..\HARDWARE\RingBuffer;..\USER;..\HARDWARE\RTC;..\HARDWARE\TIMER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c doubleRingBuffer_xiaojia.c init_xiaojia.c ringbuffer.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/TIMER/: timer.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/USART/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_sdio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_tim.c stm32f4xx_spi.c stm32f4xx_exti.c stm32f4xx_pwr.c stm32f4xx_rtc.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c ffunicode.c
    ../FATFS/exfuns/: exfuns.c
    ../FATFS/src/option/: cc936.c
  group README
    ../: readme.txt
